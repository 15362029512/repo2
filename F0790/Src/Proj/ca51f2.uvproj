# Keil uVision project ca51f2.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: F0790 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Core;..\Lib\Inc;..\User\Inc;..\App\Inc
  link misc: REMOVEUNUSED
  group Core
    ../Core/: ca51f_config.h ca51f2sfr.h ca51f2xsfr.h gpiodef_f2.h STARTUP.A51
  group App
    ../App/Src/: app.c key_app.c
  group Lib
    ../Lib/Src/: delay.c system_clock.c uart.c adc.c
  group User
    ../User/Inc/: bsp.h
    ../User/Src/: main.c bsp.c ring.c timer.c interrupt.c rtc.c bat.c lcd.c key.c bl.c motor.c switch.c
  group Doc
    ../Doc/: readme.txt
